COMPATIBLE_MACHINE = 'chip'